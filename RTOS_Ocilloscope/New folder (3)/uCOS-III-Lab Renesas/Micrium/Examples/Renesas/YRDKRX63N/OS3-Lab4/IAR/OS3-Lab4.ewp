# IAR project OS3-Lab4.ewp, settings and files
configuration Debug (RX, debug)
  General.OGChipSelectMenu: R5F563NB R5F563NB
  General.GenCodeModel: 0
  General.GenDataModel: 1
  General.StackSize: 0x0
  General.IStackSize: 0x200
  General.HeapSize: 0x400
  ICCRX.CCIncludePath2: $PROJ_DIR$; ..\; ..\..\BSP; ..\..\BSP\Glyph; ..\..\BSP\IAR; ..\..\BSP\OS\uCOS-III; ..\..\..\..\..\Software\uC-CPU; ..\..\..\..\..\Software\uC-CPU\RX\IAR; ..\..\..\..\..\Software\uC-LIB; ..\..\..\..\..\Software\uCOS-III\Source; ..\..\..\..\..\Software\uCOS-III\Ports\Renesas\RX\IAR
  ICCRX.IccLang: 0
  ILINK.IlinkOutputFile: OS3-Lab1.out
  ILINK.IlinkIcfFile: ..\..\BSP\IAR\lnkr5f563nb.icf
  ILINK.IlinkUStackSize: 1
  ILINK.IlinkIStackSize: 1
  ILINK.IlinkHeapSize: 1
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (RX)
  as the first configuration, except:
  ICCRX.CCDefines: NDEBUG
  group App
    ../: app.c app_cfg.h bsp_cfg.h cpu_cfg.h lib_cfg.h os_app_hooks.c os_app_hooks.h os_cfg.h os_cfg_app.h wdt.c wdt.h yrdkrx63n.h
  group BSP
    ../../BSP/: bsp.c bsp.h bsp_glcd.c bsp_glcd.h bsp_int.c bsp_int.h bsp_int_vect_tbl.c bsp_int_vect_tbl.h bsp_led.c bsp_led.h bsp_misc.c bsp_misc.h bsp_ser.c bsp_ser.h bsp_sys.c bsp_sys.h cpu_bsp.c os_bsp.c os_bsp.h
  group BSP/Glyph
    ../../BSP/Glyph/: font_8x8.c font_x5x7.c Glyph.c Glyph.h Glyph_cfg.h GlyphRegister.c ST7579_LCD.c ST7579_LCD.h types.h YRDKRX63N_RSPI0.c YRDKRX63N_RSPI0.h
  group BSP/IAR
    ../../BSP/IAR/: cstartup.s iodefine.h
  group BSP/OS
    ../../BSP/OS/uCOS-III/: bsp_os.c bsp_os.h
  group uC/CPU
    ../../../../../Software/uC-CPU/: cpu_core.c cpu_core.h cpu_def.h
  group uC/CPU/RX
    ../../../../../Software/uC-CPU/RX/IAR/: cpu.h
  group uC/LIB
    ../../../../../Software/uC-LIB/: lib_ascii.c lib_ascii.h lib_def.h lib_math.c lib_math.h lib_mem.c lib_mem.h lib_str.c lib_str.h
  group uC/OS-III/Port
    ../../../../../Software/uCOS-III/Ports/Renesas/RX/IAR/: os_cpu.h os_cpu_a.s os_cpu_c.c
  group uC/OS-III/Source
    ../../../../../Software/uCOS-III/Source/: os.h os_cfg_app.c os_core.c os_dbg.c os_flag.c os_int.c os_mem.c os_msg.c os_mutex.c os_pend_multi.c os_prio.c os_q.c os_sem.c os_stat.c os_task.c os_tick.c os_time.c os_tmr.c os_type.h os_var.c
